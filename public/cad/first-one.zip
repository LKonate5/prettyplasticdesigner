Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 20260701 First One.ifc
Time: 2026-02-10T11:20:58
Author: Unknown
Organization: Trimble Inc.
Written by: TrimBimToIFC
Made in: Trimble Inc. - SketchUp - 2026.0
Authorization: IFC4 model

# IfcBuildingElementProxy, Component#1
Material: Lisanne_Eraser
