Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 20240112 Second High.ifc
Time: 2026-02-10T11:15:41
Author: Unknown
Organization: Trimble Inc.
Written by: TrimBimToIFC
Made in: Trimble Inc. - SketchUp - 2026.0
Authorization: IFC4 model

# IfcBuildingElementProxy (10)
Name
5 x Undefined
4 x Difference
Difference | Material: [Color B02]
